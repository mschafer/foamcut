# Keil uVision project foamcut_device_lpc-p1343.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC1343FBD48 NXP
  pack: Keil.LPC1300_DFP.1.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: foamcut_device_lpc-p1343
  AfterMake: $K\ARM\bin\elfdwt.exe !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1
  c define: CFG_FOAMCUT
  c include: ..\common;..\lpc-p1343
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group core
    ./core/cpu/: cpu.c
    ./core/gpio/: gpio.c
    ./core/systick/: systick.c
    ./core/usbcdc/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group app
    ./: step_timer.c sysinit.c HAL.cpp main.cpp MemoryAllocator.cpp assert.c
  group common
    ../common/: Engine.cpp Line.cpp Message.cpp StatusFlags.cpp Stepper.cpp
target Release (ARM-ADS)
  device: LPC1343FBD48 NXP
  pack: Keil.LPC1300_DFP.1.0.0
  cpu: as above
  output: foamcut_device_lpc-p1343
  AfterMake: $K\ARM\bin\elfdwt.exe !L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3
  c define: CFG_FOAMCUT
  c include: ..\common;..\lpc-p1343
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
